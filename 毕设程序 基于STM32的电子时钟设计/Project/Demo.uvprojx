# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Hardware\inc;..\Libraries\CMSIS\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\System\inc;..\User\inc;..\Hardware\inc;..\cJSON;..\MALLOC\inc;..\UI\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/src/: main.c stm32f10x_it.c
  group Startup
    ../Libraries/CMSIS/arm/: startup_stm32f10x_md.s
  group System
    ../System/src/: Delay.c rtc.c exti.c TIM_2.c USART3_TIM3_wifi.c USART1_su30t.c USART2.c
  group Hardware
    ../Hardware/src/: Key.c LED.c WIFI.c oled.c BEEP.c
  group UI
    ../UI/src/: alarm_clock_ui.c set_time_ui.c stop_watch_ui.c weather_ui.c menu.c explain_ui.c Game_ui.c
  group CMSIS
    ../Libraries/CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Fwlib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cJSON
    ../cJSON/: cJSON.c
  group MALLOC
    ../MALLOC/src/: malloc.c
